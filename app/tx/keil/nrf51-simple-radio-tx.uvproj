# Keil uVision project nrf51-simple-radio-tx.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nrf51-simple-radio-tx +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: C:\Keil_v5\ARM\Device\Nordic\nrf51822\Include;..\..\..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c
  group core
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/: keil_arm_uv4.lnt
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/templates/: system_nrf51.c
    C:/Keil_v5/ARM/Device/Nordic/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
  group lib
    ../../../lib/: evt_queue.c queue.c radio.c rx_queue.c tx_queue.c packet.c linked_list.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: button_radio_tx_example +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: button_radio_tx_example +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: button_radio_tx_example +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: button_radio_tx_example +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: button_radio_tx_example +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
